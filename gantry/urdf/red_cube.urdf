Commit message: Incomplete conveyor motion andlaser detection

File: gantry/urdf/red_cube.urdf (robot description, URDF)
Before this commit: robot red_cube, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.07 0.07 0.07; visual box size=0.07 0.07 0.07
